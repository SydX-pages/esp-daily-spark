/* Daily rotation and web selection of the ANSI thumbnail. */

#include "art.h"

#include <string.h>
#include <time.h>

#include "ansi_art.h"
#include "esp_log.h"
#include "esp_random.h"
#include "nvs.h"

static const char *TAG = "art";

#define NVS_NS  "clock"
#define NO_DAY  0xFFFFu

enum { MODE_RANDOM = 0, MODE_FIXED = 1 };

/* Same order as the ansi_arts[] table generated by tools/gen_ansi_art.py. */
static const char *const NAMES[ANSI_ART_COUNT] = {
    "小曾曾", /* ansi: base */
    "哈哈哈", /* laugh */
    "无语",   /* speechless */
    "喜欢",   /* love */
};

_Static_assert(sizeof(NAMES) / sizeof(NAMES[0]) == ANSI_ART_COUNT,
               "one display name per embedded picture");

static uint8_t s_mode = MODE_RANDOM;
static uint8_t s_index;
static uint16_t s_day = NO_DAY;
static uint32_t s_rev;
static bool s_ready;

static uint16_t local_yday(void)
{
    time_t now = time(NULL);
    struct tm local;

    if (now < 1600000000L) {
        return NO_DAY;
    }
    localtime_r(&now, &local);
    return (uint16_t)local.tm_yday;
}

static void state_save(void)
{
    nvs_handle_t h;

    if (nvs_open(NVS_NS, NVS_READWRITE, &h) != ESP_OK) {
        ESP_LOGW(TAG, "cannot open NVS to save the picture");
        return;
    }
    esp_err_t err = nvs_set_u8(h, "a_mode", s_mode);
    if (err == ESP_OK) {
        err = nvs_set_u8(h, "a_idx", s_index);
    }
    if (err == ESP_OK) {
        err = nvs_set_u16(h, "a_day", s_day);
    }
    if (err == ESP_OK) {
        err = nvs_commit(h);
    }
    if (err != ESP_OK) {
        ESP_LOGW(TAG, "cannot save the picture: %s", esp_err_to_name(err));
    }
    nvs_close(h);
}

/* Picks a random picture different from the current one, so a change is
 * actually visible. */
static uint8_t pick_other(void)
{
    uint8_t next = s_index;

    if (ANSI_ART_COUNT > 1) {
        do {
            next = (uint8_t)(esp_random() % ANSI_ART_COUNT);
        } while (next == s_index);
    }
    return next;
}

void art_init(void)
{
    uint8_t value;

    s_mode = MODE_RANDOM;
    s_index = 0;
    s_day = NO_DAY;
    s_rev = 0;

    nvs_handle_t h;
    if (nvs_open(NVS_NS, NVS_READWRITE, &h) == ESP_OK) {
        if (nvs_get_u8(h, "a_mode", &value) == ESP_OK &&
            value <= MODE_FIXED) {
            s_mode = value;
        }
        if (nvs_get_u8(h, "a_idx", &value) == ESP_OK &&
            value < ANSI_ART_COUNT) {
            s_index = value;
        }
        if (nvs_get_u16(h, "a_day", &s_day) != ESP_OK) {
            s_day = NO_DAY;
        }
        nvs_close(h);
    }

    s_ready = true;
    ESP_LOGI(TAG, "art ready: %s, showing \"%s\"",
             s_mode == MODE_FIXED ? "fixed" : "daily random", NAMES[s_index]);
}

int art_index(void)
{
    return s_index;
}

int art_count(void)
{
    return ANSI_ART_COUNT;
}

const char *art_name(int index)
{
    return index >= 0 && index < ANSI_ART_COUNT ? NAMES[index] : "";
}

bool art_is_random(void)
{
    return s_mode == MODE_RANDOM;
}

uint32_t art_revision(void)
{
    return s_rev;
}

bool art_update_day(void)
{
    if (!s_ready || s_mode != MODE_RANDOM) {
        return false;
    }

    uint16_t yday = local_yday();
    if (yday == NO_DAY || yday == s_day) {
        return false;
    }

    s_index = pick_other();
    s_day = yday;
    s_rev++;
    state_save();
    ESP_LOGI(TAG, "new day, random picture: \"%s\"", NAMES[s_index]);
    return true;
}

bool art_set_random(void)
{
    if (ANSI_ART_COUNT <= 1) {
        return false;
    }

    s_mode = MODE_RANDOM;
    s_index = pick_other();
    s_day = local_yday();
    s_rev++;
    state_save();
    ESP_LOGI(TAG, "daily random, now showing \"%s\"", NAMES[s_index]);
    return true;
}

bool art_set_fixed(int index)
{
    if (index < 0 || index >= ANSI_ART_COUNT) {
        return false;
    }
    if (s_mode == MODE_FIXED && s_index == (uint8_t)index) {
        return false;
    }

    s_mode = MODE_FIXED;
    s_index = (uint8_t)index;
    s_day = local_yday();
    s_rev++;
    state_save();
    ESP_LOGI(TAG, "pinned picture: \"%s\"", NAMES[s_index]);
    return true;
}
